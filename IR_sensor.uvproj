# Keil uVision project IR_sensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: IR_sensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ir_lcd.h main_sys.c
